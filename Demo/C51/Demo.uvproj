# Keil uVision project Demo.uvproj, settings and files
target Demo (MCS-51)
  device: STC89C52RC STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: Demo
  c flags: Optimize=8 SizeSpeed=1
  c include: ../../Core/Inc
  group STARTUP
    ./: STARTUP.A51
  group User
    ./: main.c
  group Lib
    ../../Core/Lib/C51/: lib-code.LIB
