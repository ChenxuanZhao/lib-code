# Keil uVision project lib-code.uvproj, settings and files
target Core (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: lib-code (library)
  c flags: Optimize=8 SizeSpeed=1
  c include: ../../Core/Inc
  group Src
    ../../Core/Src/: tsc_getutf8char.c tsc_ucs2toutf8.c tsc_ucs2toutf8string.c tsc_utf8toucs2.c tsc_utf8toucs2string.c
