# Keil uVision project lib-code.uvprojx, settings and files
target Lib-code (6140000::V6.14::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: lib-code (library)
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ../../Core/Inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Src
    ../../Core/Src/: tsc_getutf8char.c tsc_ucs2toutf8.c tsc_ucs2toutf8string.c tsc_utf8toucs2.c tsc_utf8toucs2string.c
